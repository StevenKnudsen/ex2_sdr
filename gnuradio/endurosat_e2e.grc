options:
  parameters:
    generate_options: no_gui
    id: endurosat_e2e
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: aug
  id: variable
  parameters:
    value: '1'
  states: {}
- name: baud
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '100'
  states: {}
- name: fsk_dev
  id: variable
  parameters:
    value: '600'
  states: {}
- name: points
  id: variable
  parameters:
    value: int(16*8*(samp_rate/baud))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2*3.14159*(fsk_dev/samp_rate)*aug
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '4321'
    tcp_no_delay: 'False'
    type: TCP_CLIENT
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: baud
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '1234'
    psize: '1472'
    type: byte
    vlen: '1'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: int(samp_rate/baud)
    sensitivity: sensitivity
  states: {state: disabled}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: int(samp_rate/baud)
    sensitivity: sensitivity
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '256'
    srate: baud
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: points
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: baud
    iq: 'True'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_hexdump_sink_0_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {state: disabled}
- name: satellites_sync_to_pdu_packed_0_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '5'
    sync: '''01111110'''
    threshold: '0'
  states: {}
- name: satellites_sync_to_pdu_packed_0_0_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '5'
    sync: '''01111110'''
    threshold: '0'
  states: {state: disabled}

connections:
- [blocks_packed_to_unpacked_xx_0, '0', satellites_sync_to_pdu_packed_0_0_0, '0']
- [blocks_throttle_0, '0', digital_gfsk_mod_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_udp_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_udp_source_0, '0', blocks_throttle_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_sync_to_pdu_packed_0_0, '0']
- [digital_gfsk_demod_0, '0', blocks_uchar_to_float_0, '0']
- [digital_gfsk_demod_0, '0', satellites_sync_to_pdu_packed_0_0, '0']
- [digital_gfsk_mod_0, '0', digital_gfsk_demod_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_time_sink_x_1, '0']
- [digital_gfsk_mod_0, '0', satellites_fsk_demodulator_0, '0']
- [satellites_fsk_demodulator_0, '0', digital_binary_slicer_fb_0, '0']
- [satellites_sync_to_pdu_packed_0_0, out, blocks_socket_pdu_0, pdus]
- [satellites_sync_to_pdu_packed_0_0, out, satellites_hexdump_sink_0, in]
- [satellites_sync_to_pdu_packed_0_0_0, out, satellites_hexdump_sink_0_0, in]

metadata:
  file_format: 1
