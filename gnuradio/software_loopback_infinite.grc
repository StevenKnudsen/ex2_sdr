options:
  parameters:
    generate_options: qt_gui
    id: endurosat_e2e
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: baud_bit
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: baud_byte
  id: variable
  parameters:
    value: baud_bit/8
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '435000000'
  states: {}
- name: fsk_dev
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2*3.14159*(fsk_dev/baud_bit)
  states: {}
- name: spsym
  id: variable
  parameters:
    value: '160'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '0.8'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '9'
    type: byte
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters: {}
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 0, 0, 0, 1, 1, 1, 0, 1, 10, 0)
    vlen: '9'
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: spsym
    sensitivity: sensitivity
  states: {}
- name: digital_gfsk_mod_0_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: spsym
    sensitivity: sensitivity
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: 9600*160
    srate: 9600*160
    type: complex
    update_time: '1'
    ymax: '0.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '2'
    size: baud_bit*16
    srate: baud_bit
    type: float
    update_time: '16'
    ymax: '-1'
    ymin: '1'
  states: {}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {state: disabled}

connections:
- [blocks_stream_to_tagged_stream_0, '0', digital_gfsk_mod_0_0, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_uchar_to_float_0_0_1, '0', satellites_ax25_deframer_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_gfsk_demod_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_gfsk_demod_0, '0', blocks_uchar_to_float_0_0_1, '0']
- [digital_gfsk_mod_0_0, '0', digital_gfsk_demod_0, '0']
- [digital_gfsk_mod_0_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
