options:
  parameters:
    generate_options: qt_gui
    id: endurosat_e2e
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: baud_bit
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: baud_byte
  id: variable
  parameters:
    value: baud_bit/8
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '435000000'
  states: {}
- name: fsk_dev
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2*3.14159*(fsk_dev/baud_bit)
  states: {}
- name: spsym
  id: variable
  parameters:
    value: '160'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '0.8'
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '4321'
    tcp_no_delay: 'False'
    type: TCP_CLIENT
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: baud_bit
    type: byte
  states: {}
- name: blocks_uchar_to_float_0_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (170, 170, 170, 170, 170, 170, 170, 170, 170, 170, 126, 2, 69, 83, 58, 83)
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: spsym
    sensitivity: sensitivity
  states: {}
- name: digital_gfsk_mod_0_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: spsym
    sensitivity: sensitivity
  states: {}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {state: disabled}
- name: satellites_sync_to_pdu_packed_0_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '3'
    sync: '''01111110'''
    threshold: '0'
  states: {}

connections:
- [blocks_throttle_0, '0', digital_gfsk_mod_0_0, '0']
- [blocks_uchar_to_float_0_0_1, '0', satellites_ax25_deframer_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_throttle_0, '0']
- [digital_gfsk_demod_0, '0', blocks_uchar_to_float_0_0_1, '0']
- [digital_gfsk_demod_0, '0', satellites_sync_to_pdu_packed_0_0, '0']
- [digital_gfsk_mod_0_0, '0', digital_gfsk_demod_0, '0']
- [satellites_sync_to_pdu_packed_0_0, out, blocks_socket_pdu_0, pdus]

metadata:
  file_format: 1
